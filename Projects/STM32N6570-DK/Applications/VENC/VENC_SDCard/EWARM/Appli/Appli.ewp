# IAR project Appli.ewp, settings and files
configuration VENC_SDCard_Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_FULL_ASSERT; TERMINAL_IO; DEBUG; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pe188, Pe550,Pa089,Pe068
  ICCARM.CCIncludePath2: ..\..\Appli\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32N6570-DK; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\..\Drivers\BSP\Components\imx335; ..\..\..\..\..\..\..\Middlewares\ST\VideoEncoder_EWL; ..\..\..\..\..\..\..\Middlewares\Third_Party\VideoEncoder\inc; ..\..\..\..\..\..\..\Middlewares\Third_Party\VideoEncoder\source\common; ..\..\..\..\..\..\..\Middlewares\Third_Party\VideoEncoder\source\h264; ..\..\..\..\..\..\..\Middlewares\ST\STM32_ISP_Library\isp\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_ISP_Library\evision\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Appli.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32n657xx_LRUN.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration VENC_SDCard_LRUN (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32N657xx; USE_HAL_DRIVER
  ICCARM.CCOptLevel: 0
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_lcd.c stm32n6570_discovery_sd.c
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/imx335/: imx335.c imx335_reg.c
    ../../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery_camera.c
  group Drivers/CMSIS
    ./: startup_stm32n657xx.s
    ../FSBL/: startup_stm32n657xx_fsbl.s
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
    ../../Appli/Src/: system_stm32n6xx_s.c
  group Drivers/HAL
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dcmipp.c stm32n6xx_hal_gpio.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_ltdc.c stm32n6xx_hal_ltdc_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_ramcfg.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_sd.c stm32n6xx_hal_sd_ex.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_ll_sdmmc.c stm32n6xx_ll_venc.c
  group Middleware/EWL
    ../../../../../../../Middlewares/ST/VideoEncoder_EWL/: ewl_impl.c
  group Middleware/STM32_ISP
    ../../../../../../../Middlewares/ST/STM32_ISP_Library/isp/Src/: isp_algo.c isp_core.c isp_services.c
  group Middleware/STM32_ISP/evision
    ../../../../../../../Middlewares/ST/STM32_ISP_Library/evision/Lib/: libn6-evision-awb_iar.a libn6-evision-st-ae_iar.a
  group Middleware/VSI/Common
    ../../../../../../../Middlewares/Third_Party/VideoEncoder/source/common/: encasiccontroller.c encasiccontroller_v2.c encpreprocess.c encswhwregisters.c
  group Middleware/VSI/h264
    ../../../../../../../Middlewares/Third_Party/VideoEncoder/source/h264/: H264Cabac.c H264CodeFrame.c H264Denoise.c H264EncApi.c h264encapi_ext.c H264Init.c H264Mad.c H264NalUnit.c H264PictureBuffer.c H264PictureParameterSet.c H264PutBits.c H264RateControl.c H264Sei.c H264SequenceParameterSet.c H264Slice.c
  group User
    ../../Appli/Src/: main.c stm32n6xx_it.c
