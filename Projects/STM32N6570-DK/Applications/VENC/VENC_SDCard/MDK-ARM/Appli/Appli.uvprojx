# Keil uVision project Appli.uvprojx, settings and files
target VENC_SDCard_Appli (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x341C0000-0x341FFFFF) IROM(0x34180400-0x341C03FF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: Project +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32N657xx,USE_FULL_ASSERT,USE_HAL_DRIVER,DEBUG
  c include: ../../Appli/Inc;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../../Drivers/BSP/STM32N6570-DK;../../../../../../../Drivers/BSP/Components/Common;../../../../../../../Drivers/BSP/Components/imx335;../../../../../../../Middlewares/ST/VideoEncoder_EWL;../../../../../../../Middlewares/Third_Party/VideoEncoder/inc;../../../../../../../Middlewares/Third_Party/VideoEncoder/source/common;../../../../../../../Middlewares/Third_Party/VideoEncoder/source/h264;../../../../../../../Middlewares/ST/STM32_ISP_Library/isp/Inc;../../../../../../../Middlewares/ST/STM32_ISP_Library/evision/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x34000400 size 0x3fc00
  memory RVCT9: RAM 0x341b7000 size 0x249000
  scatter file: stm32n657xx_LRUN.sct
  link misc: --map --list=image.lst
  group Application/MDK-ARM
    ../: startup_stm32n657xx.c startup_stm32n657xx_fsbl.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_lcd.c stm32n6570_discovery_sd.c stm32n6570_discovery_camera.c
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/imx335/: imx335.c imx335_reg.c
  group Drivers/CMSIS
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
    ../../Appli/Src/: system_stm32n6xx_s.c
  group Drivers/HAL
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dcmipp.c stm32n6xx_hal_gpio.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_ltdc.c stm32n6xx_hal_ltdc_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_ramcfg.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_sd.c stm32n6xx_hal_sd_ex.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_ll_sdmmc.c stm32n6xx_ll_venc.c stm32n6xx_hal_exti.c stm32n6xx_hal_dma2d.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_bsec.c
  group Middleware/EWL
    ../../../../../../../Middlewares/ST/VideoEncoder_EWL/: ewl_impl.c
  group Middleware/STM32_ISP
    ../../../../../../../Middlewares/ST/STM32_ISP_Library/isp/Src/: isp_algo.c isp_core.c isp_services.c
  group Middleware/STM32_ISP/evision
    ../../../../../../../Middlewares/ST/STM32_ISP_Library/evision/Lib/: libn6-evision-awb_keil.a libn6-evision-st-ae_keil.a
  group Middleware/VSI/Common
    ../../../../../../../Middlewares/Third_Party/VideoEncoder/source/common/: encasiccontroller.c encasiccontroller_v2.c encpreprocess.c encswhwregisters.c
  group Middleware/VSI/h264
    ../../../../../../../Middlewares/Third_Party/VideoEncoder/source/h264/: H264Cabac.c H264CodeFrame.c H264Denoise.c H264EncApi.c h264encapi_ext.c H264Init.c H264Mad.c H264NalUnit.c H264PictureBuffer.c H264PictureParameterSet.c H264PutBits.c H264RateControl.c H264Sei.c H264SequenceParameterSet.c H264Slice.c H264TestId.c
  group User
    ../../Appli/Src/: main.c stm32n6xx_it.c
target VENC_SDCard_LRUN (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: as above
  output: Project +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32N657xx,USE_HAL_DRIVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x34000400 size 0x3fc00
  memory RVCT9: RAM 0x341b7000 size 0x249000
  scatter file: .\stm32n657xx_LRUN.sct
software components: CMSIS:CORE 5.6.0
