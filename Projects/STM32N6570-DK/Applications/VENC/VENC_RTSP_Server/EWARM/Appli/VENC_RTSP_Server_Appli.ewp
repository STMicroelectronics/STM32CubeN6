# IAR project VENC_RTSP_Server_Appli.ewp, settings and files
configuration VENC_RTSP_Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: NX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE; USE_HAL_DRIVER; STM32N657xx; XXXTERMINAL_IO; TX_SINGLE_MODE_SECURE=1; ETH_PHY_1000MBITS_SUPPORTED; USE_AUDIO_CODEC_WM8904; ETH_MTL_TX_Q_CNT=1; ETH_MTL_RX_Q_CNT=1; ETH_DMA_TX_CH_CNT=1; ETH_DMA_RX_CH_CNT=1; ETH_TX_DESC_CNT=64; ETH_RX_DESC_CNT=10
  ICCARM.CCIncludePath2: ..\..\Appli\libsndfile\src\G72x; ..\..\Appli\NetXDuo\App; ..\..\Appli\NetXDuo\Target; ..\..\Appli\Core\Inc; ..\..\Appli\adpcm\src; ..\..\Appli\AZURE_RTOS\App; ..\..\..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\Components\rtl8211; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\..\..\..\..\..\..\Middlewares\ST\threadx\common\inc; ..\..\..\..\..\..\..\Middlewares\ST\threadx\ports\cortex_m55\iar\inc; ..\..\..\..\..\..\..\Middlewares\ST\threadx\utility\execution_profile_kit; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\addons\dhcp; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\addons\rtsp; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\addons\rtp; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\link\inc; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\common\drivers\ethernet; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\common\inc; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\ports\cortex_m55\iar\inc; ..\..\..\..\..\..\..\Middlewares\Third_Party\VideoEncoder\inc; ..\..\..\..\..\..\..\Middlewares\ST\VideoEncoder_EWL; ..\..\..\..\..\..\..\Middlewares\Third_Party\VideoEncoder\source\common; ..\..\..\..\..\..\..\Middlewares\Third_Party\VideoEncoder\source\h264; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\..\Drivers\BSP\STM32N6570-DK; ..\..\..\..\..\..\..\Drivers\BSP\Components\imx335; ..\..\..\..\..\..\..\Middlewares\ST\STM32_ISP_Library\evision\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_ISP_Library\isp\Inc; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\tsn\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: TX_SINGLE_MODE_SECURE=1; TX_INCLUDE_USER_DEFINE_FILE
  AARM.AUserIncludes: ..\..\Appli\Core\Inc
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32n657xx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration VENC_PCM_RTSP_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NX_INCLUDE_USER_DEFINE_FILE; TX_INCLUDE_USER_DEFINE_FILE; USE_HAL_DRIVER; STM32N657xx; XXXTERMINAL_IO; TX_SINGLE_MODE_SECURE=1; ETH_PHY_1000MBITS_SUPPORTED; USE_AUDIO_CODEC_WM8904; HAVE_CONFIG_H; ETH_MTL_TX_Q_CNT=1; ETH_MTL_RX_Q_CNT=1; ETH_DMA_TX_CH_CNT=1; ETH_DMA_RX_CH_CNT=1; ETH_TX_DESC_CNT=64; ETH_RX_DESC_CNT=10
  ICCARM.CCIncludePath2: ..\..\Appli\libsndfile\src\G72x; ..\..\Appli\NetXDuo\App; ..\..\Appli\NetXDuo\Target; ..\..\Appli\Core\Inc; ..\..\Appli\adpcm\src; ..\..\Appli\AZURE_RTOS\App; ..\..\..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\Components\rtl8211; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\..\..\..\..\..\..\Middlewares\ST\threadx\common\inc; ..\..\..\..\..\..\..\Middlewares\ST\threadx\ports\cortex_m55\iar\inc; ..\..\..\..\..\..\..\Middlewares\ST\threadx\utility\execution_profile_kit; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\addons\dhcp; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\addons\rtsp; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\addons\rtp; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\link\inc; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\common\drivers\ethernet; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\common\inc; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\ports\cortex_m55\iar\inc; ..\..\..\..\..\..\..\Middlewares\Third_Party\VideoEncoder\inc; ..\..\..\..\..\..\..\Middlewares\ST\VideoEncoder_EWL; ..\..\..\..\..\..\..\Middlewares\Third_Party\VideoEncoder\source\common; ..\..\..\..\..\..\..\Middlewares\Third_Party\VideoEncoder\source\h264; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\..\Drivers\BSP\STM32N6570-DK; ..\..\..\..\..\..\..\Drivers\BSP\Components\imx335; ..\..\..\..\..\..\..\Middlewares\ST\STM32_ISP_Library\evision\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_ISP_Library\isp\Inc; ..\..\..\..\..\..\..\Middlewares\ST\netxduo\tsn\inc; ..\..\..\..\..\..\..\Middlewares\Third_Party\Opus\celt; ..\..\..\..\..\..\..\Middlewares\Third_Party\Opus\celt\arm; ..\..\..\..\..\..\..\Middlewares\Third_Party\Opus\include; ..\..\..\..\..\..\..\Middlewares\Third_Party\Opus\silk; ..\..\..\..\..\..\..\Middlewares\Third_Party\Opus\silk\arm; ..\..\..\..\..\..\..\Middlewares\Third_Party\Opus\silk\fixed; ..\..\..\..\..\..\..\Middlewares\Third_Party\Opus\src; ..\..\..\..\..\..\..\Middlewares\Third_Party\Opus
configuration VENC_OPUS_RTSP_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 2
  group Application/EWARM
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
    ../../Appli/Core/Src/: system_stm32n6xx_s.c
  group Application/User/Audio
    ../../Appli/Core/Src/: stm32n6570_discovery_audio_multi.c
  group Application/User/Audio/Opus
    ../../Appli/Core/Src/: opus_app.c
    ../../Appli/NetXDuo/App/: opus_over_rtp.c
  group Application/User/Audio/PCM
    ../../Appli/Core/Src/: pcm_app.c
    ../../Appli/NetXDuo/App/: pcm_over_rtp.c
  group Application/User/AZURE_RTOS/App
    ../../Appli/AZURE_RTOS/App/: app_azure_rtos.c
  group Application/User/Core
    ../../Appli/Core/Src/: app_threadx.c dcmipp_app.c frame_rb.c main.c stm32n6xx_hal_msp.c stm32n6xx_hal_timebase_tim.c stm32n6xx_it.c SystemClock_Config_600MHz.c SystemClock_Config_800MHz.c tx_initialize_low_level.S venc_app.c venc_h264_config.c
  group Application/User/Monitoring
    ../../Appli/Core/Src/: st_monitor.c st_monitor_bitrate.c st_monitor_cpu_threadx.c st_monitor_network.c time_monitor.c
  group Application/User/NetXDuo/App
    ../../Appli/NetXDuo/App/: app_netxduo.c app_rtsp_over_rtp.c
  group Application/User/Patch
    ../../Appli/Core/Src/Patch/: nx_stm32_eth_driver.c stm32n6570_discovery_camera.c
  group Doc
    ../../: README.md
  group Middlewares/Interfaces/Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/aps256xx/: aps256xx.c
    ../../../../../../../Drivers/BSP/Components/imx335/: imx335.c imx335_reg.c
    ../../../../../../../Drivers/BSP/Components/mx66uw1g45g/: mx66uw1g45g.c
    ../../../../../../../Drivers/BSP/Components/rtl8211/: rtl8211.c
    ../../../../../../../Drivers/BSP/Components/wm8904/: wm8904.c wm8904_reg.c
  group Middlewares/Interfaces/Drivers/BSP/STM32N6570-DK
    ../../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_camera.c stm32n6570_discovery_lcd.c stm32n6570_discovery_xspi.c
  group Middlewares/Interfaces/Drivers/CMSIS
    ./: startup_stm32n657xx.s
  group Middlewares/Interfaces/Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dcmipp.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma2d.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_eth.c stm32n6xx_hal_eth_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_icache.c stm32n6xx_hal_ltdc.c stm32n6xx_hal_ltdc_ex.c stm32n6xx_hal_mdf.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_ramcfg.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_sai.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_xspi.c stm32n6xx_ll_venc.c
  group Middlewares/Interfaces/Network/Ethernet Interface
    ../../../../../../../Middlewares/ST/netxduo/common/drivers/ethernet/: nx_stm32_eth_driver.c
    ../../../../../../../Middlewares/ST/netxduo/common/drivers/ethernet/rtl8211/: nx_stm32_phy_driver.c
  group Middlewares/NetXDuo/Addons DHCP Client
    ../../../../../../../Middlewares/ST/netxduo/addons/dhcp/: nxd_dhcp_client.c nxd_dhcpv6_client.c
  group Middlewares/NetXDuo/Addons RTP
    ../../../../../../../Middlewares/ST/netxduo/addons/rtp/: nx_rtp_sender.c
  group Middlewares/NetXDuo/Addons RTSP
    ../../../../../../../Middlewares/ST/netxduo/addons/rtsp/: nx_rtsp_server.c
  group Middlewares/NetXDuo/NX Core
    ../../../../../../../Middlewares/ST/netxduo/common/src/: nx_arp_announce_send.c nx_arp_dynamic_entries_invalidate.c nx_arp_dynamic_entry_delete.c nx_arp_dynamic_entry_set.c nx_arp_enable.c nx_arp_entry_allocate.c nx_arp_entry_delete.c nx_arp_gratuitous_send.c nx_arp_hardware_address_find.c nx_arp_info_get.c nx_arp_initialize.c nx_arp_interface_entries_delete.c nx_arp_ip_address_find.c nx_arp_packet_deferred_receive.c nx_arp_packet_receive.c nx_arp_packet_send.c nx_arp_periodic_update.c nx_arp_probe_send.c nx_arp_queue_process.c nx_arp_queue_send.c nx_arp_static_entries_delete.c nx_arp_static_entry_create.c nx_arp_static_entry_delete.c nx_arp_static_entry_delete_internal.c nx_icmp_cleanup.c nx_icmp_enable.c nx_icmp_info_get.c nx_icmp_interface_ping.c nx_icmp_interface_ping6.c nx_icmp_packet_process.c nx_icmp_packet_receive.c nx_icmp_ping.c nx_icmp_ping6.c nx_icmp_queue_process.c nx_icmpv4_packet_process.c nx_icmpv4_process_echo_reply.c nx_icmpv4_process_echo_request.c nx_icmpv4_send_error_message.c nx_igmp_enable.c nx_igmp_info_get.c nx_igmp_interface_report_send.c nx_igmp_loopback_disable.c nx_igmp_loopback_enable.c nx_igmp_multicast_check.c nx_igmp_multicast_interface_join.c nx_igmp_multicast_interface_join_internal.c nx_igmp_multicast_interface_leave.c nx_igmp_multicast_interface_leave_internal.c nx_igmp_multicast_join.c nx_igmp_multicast_leave.c nx_igmp_packet_process.c nx_igmp_packet_receive.c nx_igmp_periodic_processing.c nx_igmp_queue_process.c nx_invalidate_destination_entry.c nx_ip_address_change_notify.c nx_ip_address_get.c nx_ip_address_set.c nx_ip_auxiliary_packet_pool_set.c nx_ip_checksum_compute.c nx_ip_create.c nx_ip_deferred_link_status_process.c nx_ip_delete.c nx_ip_delete_queue_clear.c nx_ip_dispatch_process.c nx_ip_driver_deferred_enable.c nx_ip_driver_deferred_processing.c nx_ip_driver_deferred_receive.c nx_ip_driver_direct_command.c nx_ip_driver_interface_direct_command.c nx_ip_driver_link_status_event.c nx_ip_driver_packet_send.c nx_ip_fast_periodic_timer_entry.c nx_ip_forward_packet_process.c nx_ip_forwarding_disable.c nx_ip_forwarding_enable.c nx_ip_fragment_assembly.c nx_ip_fragment_disable.c nx_ip_fragment_enable.c nx_ip_fragment_forward_packet.c nx_ip_fragment_packet.c nx_ip_fragment_timeout_check.c nx_ip_gateway_address_clear.c nx_ip_gateway_address_get.c nx_ip_gateway_address_set.c nx_ip_header_add.c nx_ip_info_get.c nx_ip_initialize.c nx_ip_interface_address_get.c nx_ip_interface_address_mapping_configure.c nx_ip_interface_address_set.c nx_ip_interface_attach.c nx_ip_interface_capability_get.c nx_ip_interface_capability_set.c nx_ip_interface_detach.c nx_ip_interface_info_get.c nx_ip_interface_mtu_set.c nx_ip_interface_physical_address_get.c nx_ip_interface_physical_address_set.c nx_ip_interface_status_check.c nx_ip_link_status_change_notify_set.c nx_ip_max_payload_size_find.c nx_ip_packet_checksum_compute.c nx_ip_packet_deferred_receive.c nx_ip_packet_receive.c nx_ip_packet_send.c nx_ip_periodic_timer_entry.c nx_ip_raw_packet_cleanup.c nx_ip_raw_packet_disable.c nx_ip_raw_packet_enable.c nx_ip_raw_packet_filter_set.c nx_ip_raw_packet_processing.c nx_ip_raw_packet_receive.c nx_ip_raw_packet_send.c nx_ip_raw_packet_source_send.c nx_ip_raw_receive_queue_max_set.c nx_ip_route_find.c nx_ip_static_route_add.c nx_ip_static_route_delete.c nx_ip_status_check.c nx_ip_thread_entry.c nx_ipv4_multicast_interface_join.c nx_ipv4_multicast_interface_leave.c nx_ipv4_option_process.c nx_ipv4_packet_receive.c nx_link.c nx_md5.c nx_packet_allocate.c nx_packet_copy.c nx_packet_data_adjust.c nx_packet_data_append.c nx_packet_data_extract_offset.c nx_packet_data_retrieve.c nx_packet_debug_info_get.c nx_packet_length_get.c nx_packet_pool_cleanup.c nx_packet_pool_create.c nx_packet_pool_delete.c nx_packet_pool_info_get.c nx_packet_pool_initialize.c nx_packet_pool_low_watermark_set.c nx_packet_release.c nx_packet_transmit_release.c nx_packet_vlan_priority_set.c nx_rarp_disable.c nx_rarp_enable.c nx_rarp_info_get.c nx_rarp_packet_deferred_receive.c nx_rarp_packet_receive.c nx_rarp_packet_send.c nx_rarp_periodic_update.c nx_rarp_queue_process.c nx_system_initialize.c nx_tcp_cleanup_deferred.c nx_tcp_client_bind_cleanup.c nx_tcp_client_socket_bind.c nx_tcp_client_socket_connect.c nx_tcp_client_socket_port_get.c nx_tcp_client_socket_unbind.c nx_tcp_connect_cleanup.c nx_tcp_deferred_cleanup_check.c nx_tcp_disconnect_cleanup.c nx_tcp_enable.c nx_tcp_fast_periodic_processing.c nx_tcp_free_port_find.c nx_tcp_info_get.c nx_tcp_initialize.c nx_tcp_mss_option_get.c nx_tcp_no_connection_reset.c nx_tcp_packet_process.c nx_tcp_packet_receive.c nx_tcp_packet_send_ack.c nx_tcp_packet_send_control.c nx_tcp_packet_send_fin.c nx_tcp_packet_send_probe.c nx_tcp_packet_send_rst.c nx_tcp_packet_send_syn.c nx_tcp_periodic_processing.c nx_tcp_queue_process.c nx_tcp_receive_cleanup.c nx_tcp_server_socket_accept.c nx_tcp_server_socket_listen.c nx_tcp_server_socket_relisten.c nx_tcp_server_socket_unaccept.c nx_tcp_server_socket_unlisten.c nx_tcp_socket_block_cleanup.c nx_tcp_socket_bytes_available.c nx_tcp_socket_connection_reset.c nx_tcp_socket_create.c nx_tcp_socket_delete.c nx_tcp_socket_disconnect.c nx_tcp_socket_disconnect_complete_notify.c nx_tcp_socket_establish_notify.c nx_tcp_socket_info_get.c nx_tcp_socket_mss_get.c nx_tcp_socket_mss_peer_get.c nx_tcp_socket_mss_set.c nx_tcp_socket_packet_process.c nx_tcp_socket_peer_info_get.c nx_tcp_socket_queue_depth_notify_set.c nx_tcp_socket_receive.c nx_tcp_socket_receive_notify.c nx_tcp_socket_receive_queue_flush.c nx_tcp_socket_receive_queue_max_set.c nx_tcp_socket_retransmit.c nx_tcp_socket_send.c nx_tcp_socket_send_internal.c nx_tcp_socket_state_ack_check.c nx_tcp_socket_state_closing.c nx_tcp_socket_state_data_check.c nx_tcp_socket_state_established.c nx_tcp_socket_state_fin_wait1.c nx_tcp_socket_state_fin_wait2.c nx_tcp_socket_state_last_ack.c nx_tcp_socket_state_syn_received.c nx_tcp_socket_state_syn_sent.c nx_tcp_socket_state_transmit_check.c nx_tcp_socket_state_wait.c nx_tcp_socket_thread_resume.c nx_tcp_socket_thread_suspend.c nx_tcp_socket_timed_wait_callback.c nx_tcp_socket_transmit_configure.c nx_tcp_socket_transmit_queue_flush.c nx_tcp_socket_window_update_notify_set.c nx_tcp_transmit_cleanup.c nx_tcp_window_scaling_option_get.c nx_trace_event_insert.c nx_trace_event_update.c nx_trace_object_register.c nx_trace_object_unregister.c nx_udp_bind_cleanup.c nx_udp_enable.c nx_udp_free_port_find.c nx_udp_info_get.c nx_udp_packet_info_extract.c nx_udp_packet_receive.c nx_udp_receive_cleanup.c nx_udp_socket_bind.c nx_udp_socket_bytes_available.c nx_udp_socket_checksum_disable.c nx_udp_socket_checksum_enable.c nx_udp_socket_create.c nx_udp_socket_delete.c nx_udp_socket_info_get.c nx_udp_socket_port_get.c nx_udp_socket_receive.c nx_udp_socket_receive_notify.c nx_udp_socket_send.c nx_udp_socket_source_send.c nx_udp_socket_unbind.c nx_udp_source_extract.c nx_utility.c nxd_icmp_enable.c nxd_icmp_ping.c nxd_icmp_source_ping.c nxd_icmpv6_ra_flag_callback_set.c nxd_ip_raw_packet_send.c nxd_ip_raw_packet_source_send.c nxd_nd_cache_entry_delete.c nxd_nd_cache_entry_set.c nxd_nd_cache_hardware_address_find.c nxd_nd_cache_invalidate.c nxd_nd_cache_ip_address_find.c nxd_tcp_client_socket_connect.c nxd_tcp_socket_peer_info_get.c nxd_udp_packet_info_extract.c nxd_udp_socket_send.c nxd_udp_socket_source_send.c nxd_udp_source_extract.c nxde_icmp_enable.c nxde_icmp_ping.c nxde_icmp_source_ping.c nxde_icmpv6_ra_flag_callback_set.c nxde_ip_raw_packet_send.c nxde_ip_raw_packet_source_send.c nxde_tcp_client_socket_connect.c nxde_tcp_socket_peer_info_get.c nxde_udp_packet_info_extract.c nxde_udp_socket_send.c nxde_udp_socket_source_send.c nxde_udp_source_extract.c nxe_arp_dynamic_entries_invalidate.c nxe_arp_dynamic_entry_set.c nxe_arp_enable.c nxe_arp_entry_delete.c nxe_arp_gratuitous_send.c nxe_arp_hardware_address_find.c nxe_arp_info_get.c nxe_arp_ip_address_find.c nxe_arp_static_entries_delete.c nxe_arp_static_entry_create.c nxe_arp_static_entry_delete.c nxe_icmp_enable.c nxe_icmp_info_get.c nxe_icmp_ping.c nxe_igmp_enable.c nxe_igmp_info_get.c nxe_igmp_loopback_disable.c nxe_igmp_loopback_enable.c nxe_igmp_multicast_interface_join.c nxe_igmp_multicast_interface_leave.c nxe_igmp_multicast_join.c nxe_igmp_multicast_leave.c nxe_ip_address_change_notify.c nxe_ip_address_get.c nxe_ip_address_set.c nxe_ip_auxiliary_packet_pool_set.c nxe_ip_create.c nxe_ip_delete.c nxe_ip_driver_direct_command.c nxe_ip_driver_interface_direct_command.c nxe_ip_forwarding_disable.c nxe_ip_forwarding_enable.c nxe_ip_fragment_disable.c nxe_ip_fragment_enable.c nxe_ip_gateway_address_clear.c nxe_ip_gateway_address_get.c nxe_ip_gateway_address_set.c nxe_ip_info_get.c nxe_ip_interface_address_get.c nxe_ip_interface_address_mapping_configure.c nxe_ip_interface_address_set.c nxe_ip_interface_attach.c nxe_ip_interface_capability_get.c nxe_ip_interface_capability_set.c nxe_ip_interface_detach.c nxe_ip_interface_info_get.c nxe_ip_interface_mtu_set.c nxe_ip_interface_physical_address_get.c nxe_ip_interface_physical_address_set.c nxe_ip_interface_status_check.c nxe_ip_link_status_change_notify_set.c nxe_ip_max_payload_size_find.c nxe_ip_raw_packet_disable.c nxe_ip_raw_packet_enable.c nxe_ip_raw_packet_filter_set.c nxe_ip_raw_packet_receive.c nxe_ip_raw_packet_send.c nxe_ip_raw_packet_source_send.c nxe_ip_raw_receive_queue_max_set.c nxe_ip_static_route_add.c nxe_ip_static_route_delete.c nxe_ip_status_check.c nxe_ipv4_multicast_interface_join.c nxe_ipv4_multicast_interface_leave.c nxe_packet_allocate.c nxe_packet_copy.c nxe_packet_data_append.c nxe_packet_data_extract_offset.c nxe_packet_data_retrieve.c nxe_packet_length_get.c nxe_packet_pool_create.c nxe_packet_pool_delete.c nxe_packet_pool_info_get.c nxe_packet_pool_low_watermark_set.c nxe_packet_release.c nxe_packet_transmit_release.c nxe_packet_vlan_priority_set.c nxe_rarp_disable.c nxe_rarp_enable.c nxe_rarp_info_get.c nxe_tcp_client_socket_bind.c nxe_tcp_client_socket_connect.c nxe_tcp_client_socket_port_get.c nxe_tcp_client_socket_unbind.c nxe_tcp_enable.c nxe_tcp_free_port_find.c nxe_tcp_info_get.c nxe_tcp_server_socket_accept.c nxe_tcp_server_socket_listen.c nxe_tcp_server_socket_relisten.c nxe_tcp_server_socket_unaccept.c nxe_tcp_server_socket_unlisten.c nxe_tcp_socket_bytes_available.c nxe_tcp_socket_create.c nxe_tcp_socket_delete.c nxe_tcp_socket_disconnect.c nxe_tcp_socket_disconnect_complete_notify.c nxe_tcp_socket_establish_notify.c nxe_tcp_socket_info_get.c nxe_tcp_socket_mss_get.c nxe_tcp_socket_mss_peer_get.c nxe_tcp_socket_mss_set.c nxe_tcp_socket_peer_info_get.c nxe_tcp_socket_queue_depth_notify_set.c nxe_tcp_socket_receive.c nxe_tcp_socket_receive_notify.c nxe_tcp_socket_receive_queue_max_set.c nxe_tcp_socket_send.c nxe_tcp_socket_state_wait.c nxe_tcp_socket_timed_wait_callback.c nxe_tcp_socket_transmit_configure.c nxe_tcp_socket_window_update_notify_set.c nxe_udp_enable.c nxe_udp_free_port_find.c nxe_udp_info_get.c nxe_udp_packet_info_extract.c nxe_udp_socket_bind.c nxe_udp_socket_bytes_available.c nxe_udp_socket_checksum_disable.c nxe_udp_socket_checksum_enable.c nxe_udp_socket_create.c nxe_udp_socket_delete.c nxe_udp_socket_info_get.c nxe_udp_socket_port_get.c nxe_udp_socket_receive.c nxe_udp_socket_receive_notify.c nxe_udp_socket_send.c nxe_udp_socket_source_send.c nxe_udp_socket_unbind.c nxe_udp_source_extract.c
    ../../../../../../../Middlewares/ST/netxduo/tsn/src/: nx_shaper.c
  group Middlewares/Opus/Celt
    ../../../../../../../Middlewares/Third_Party/opus/celt/: bands.c celt.c celt_decoder.c celt_encoder.c celt_lpc.c cwrs.c entcode.c entdec.c entenc.c kiss_fft.c laplace.c mathops.c mdct.c mini_kfft.c modes.c pitch.c quant_bands.c rate.c vq.c
  group Middlewares/Opus/Celt/arm
    ../../../../../../../Middlewares/Third_Party/opus/celt/arm/: arm_celt_map.c armcpu.c
  group Middlewares/Opus/silk
    ../../../../../../../Middlewares/Third_Party/opus/silk/: A2NLSF.c ana_filt_bank_1.c biquad_alt.c bwexpander.c bwexpander_32.c check_control_input.c CNG.c code_signs.c control_audio_bandwidth.c control_codec.c control_SNR.c debug.c dec_API.c decode_core.c decode_frame.c decode_indices.c decode_parameters.c decode_pitch.c decode_pulses.c decoder_set_fs.c enc_API.c encode_indices.c encode_pulses.c gain_quant.c HP_variable_cutoff.c init_decoder.c init_encoder.c inner_prod_aligned.c interpolate.c lin2log.c log2lin.c LP_variable_cutoff.c LPC_analysis_filter.c LPC_fit.c LPC_inv_pred_gain.c NLSF2A.c NLSF_decode.c NLSF_del_dec_quant.c NLSF_encode.c NLSF_stabilize.c NLSF_unpack.c NLSF_VQ.c NLSF_VQ_weights_laroia.c NSQ.c NSQ_del_dec.c pitch_est_tables.c PLC.c process_NLSFs.c quant_LTP_gains.c resampler.c resampler_down2.c resampler_down2_3.c resampler_private_AR2.c resampler_private_down_FIR.c resampler_private_IIR_FIR.c resampler_private_up2_HQ.c resampler_rom.c shell_coder.c sigm_Q15.c sort.c stereo_decode_pred.c stereo_encode_pred.c stereo_find_predictor.c stereo_LR_to_MS.c stereo_MS_to_LR.c stereo_quant_pred.c sum_sqr_shift.c table_LSF_cos.c tables_gain.c tables_LTP.c tables_NLSF_CB_NB_MB.c tables_NLSF_CB_WB.c tables_other.c tables_pitch_lag.c tables_pulses_per_block.c VAD.c VQ_WMat_EC.c
  group Middlewares/Opus/silk/fixed
    ../../../../../../../Middlewares/Third_Party/opus/silk/fixed/: apply_sine_window_FIX.c autocorr_FIX.c burg_modified_FIX.c corrMatrix_FIX.c encode_frame_FIX.c find_LPC_FIX.c find_LTP_FIX.c find_pitch_lags_FIX.c find_pred_coefs_FIX.c k2a_FIX.c k2a_Q16_FIX.c LTP_analysis_filter_FIX.c LTP_scale_ctrl_FIX.c noise_shape_analysis_FIX.c pitch_analysis_core_FIX.c process_gains_FIX.c regularize_correlations_FIX.c residual_energy16_FIX.c residual_energy_FIX.c schur64_FIX.c schur_FIX.c vector_ops_FIX.c warped_autocorrelation_FIX.c
  group Middlewares/Opus/src
    ../../../../../../../Middlewares/Third_Party/opus/src/: analysis.c extensions.c mlp.c mlp_data.c opus.c opus_decoder.c opus_encoder.c opus_multistream.c opus_multistream_encoder.c repacketizer.c
  group Middlewares/STM32_ISP
    ../../../../../../../Middlewares/ST/STM32_ISP_Library/isp/Src/: isp_algo.c isp_core.c isp_services.c
  group Middlewares/STM32_ISP/evision
    ../../../../../../../Middlewares/ST/STM32_ISP_Library/evision/Lib/: libn6-evision-awb_iar.a libn6-evision-st-ae_iar.a
  group Middlewares/ThreadX
    ../../../../../../../Middlewares/ST/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
    ../../../../../../../Middlewares/ST/threadx/ports/cortex_m55/iar/src/: tx_iar.c tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_secure_stack.c tx_thread_secure_stack_allocate.s tx_thread_secure_stack_free.s tx_thread_secure_stack_initialize.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s txe_thread_secure_stack_allocate.c txe_thread_secure_stack_free.c
  group Middlewares/ThreadX/Utilities
    ../../../../../../../Middlewares/ST/threadx/utility/execution_profile_kit/: tx_execution_profile.c
  group Middlewares/VideoEncode/Common
    ../../../../../../../Middlewares/Third_Party/VideoEncoder/source/common/: encasiccontroller.c encasiccontroller_v2.c encpreprocess.c encswhwregisters.c
  group Middlewares/VideoEncode/EWL
    ../../../../../../../Middlewares/ST/VideoEncoder_EWL/: ewl_impl.c
  group Middlewares/VideoEncode/H264
    ../../../../../../../Middlewares/Third_Party/VideoEncoder/source/h264/: H264Cabac.c H264CodeFrame.c H264Denoise.c H264EncApi.c h264encapi_ext.c H264Init.c H264Mad.c H264NalUnit.c H264PictureBuffer.c H264PictureParameterSet.c H264PutBits.c H264RateControl.c H264Sei.c H264SequenceParameterSet.c H264Slice.c
