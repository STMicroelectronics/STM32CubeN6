# Keil uVision project Ux_Device_Audio2.0_PlayBack_FSBL.uvprojx, settings and files
target Ux_Device_Audio2.0_PlayBack_FSBL (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x341C0000-0x341FFFFF) IROM(0x34180400-0x341C03FF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: Ux_Device_Audio_2_0_PlayBack_FSBL +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N657xx,USE_FULL_LL_DRIVER,TX_INCLUDE_USER_DEFINE_FILE,TX_SINGLE_MODE_SECURE=1,USBPD_PORT_COUNT=1,_SNK,USBPDCORE_LIB_NO_PD,UX_INCLUDE_USER_DEFINE_FILE,TCPP0203_SUPPORT,USE_AUDIO_CODEC_WM8904,TX_EXECUTION_PROFILE_ENABLE
  c include: ../../FSBL/Core/Inc;../../FSBL/AZURE_RTOS/App;../../FSBL/USBPD/App;../../FSBL/USBPD/Target;../../FSBL/USBX/App;../../FSBL/USBX/Target;../../../../../../../Drivers/BSP/STM32N6570-DK;../../../../../../../Drivers/BSP/Components/tcpp0203;../../../../../../../Drivers/BSP/Components/wm8904;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy;../../../../../../../Middlewares/ST/threadx/common/inc;../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc;../../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32N6XX/inc;../../../../../../../Middlewares/ST/threadx/ports/cortex_m55/ac6/inc;../../../../../../../Middlewares/ST/usbx/common/core/inc;../../../../../../../Middlewares/ST/usbx/ports/generic/inc;../../../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers;../../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/inc;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/BSP/Components/cs42l51
  asm define: TX_INCLUDE_USER_DEFINE_FILE,TX_SINGLE_MODE_SECURE=1,TX_EXECUTION_PROFILE_ENABLE
  asm include: ../../FSBL/Core/Inc;../../FSBL/AZURE_RTOS/App;../../FSBL/USBPD/App;../../FSBL/USBPD/Target;../../FSBL/USBX/App;../../FSBL/USBX/Target;../../../../../../../Drivers/BSP/STM32N6570-DK;../../../../../../../Drivers/BSP/Components/tcpp0203;../../../../../../../Drivers/BSP/Components/wm8904;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy;../../../../../../../Middlewares/ST/threadx/common/inc;../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc;../../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32N6XX/inc;../../../../../../../Middlewares/ST/threadx/ports/cortex_m55/ac6/inc;../../../../../../../Middlewares/ST/usbx/common/core/inc;../../../../../../../Middlewares/ST/usbx/ports/generic/inc;../../../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers;../../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/inc;../../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT9: RAM 0x341c0000 size 0x40000
  scatter file: stm32n657xx_axisram2_fsbl.sct
  group Application/MDK-ARM
    ../: startup_stm32n657xx_fsbl.c
  group Application/User/FSBL/Core
    ../../FSBL/Core/Src/: main.c tx_initialize_low_level.S gpio.c gpdma.c app_threadx.c ucpd.c usart.c usb_otg.c stm32n6xx_it.c stm32n6xx_hal_msp.c stm32n6xx_hal_timebase_tim.c
  group Application/User/FSBL/USBPD/App
    ../../FSBL/USBPD/App/: usbpd.c usbpd_dpm_core.c usbpd_pwr_if.c usbpd_usb_if.c
  group Application/User/FSBL/USBPD/Target
    ../../FSBL/USBPD/Target/: usbpd_dpm_user.c usbpd_pwr_user.c
  group Application/User/FSBL/AZURE_RTOS/App
    ../../FSBL/AZURE_RTOS/App/: app_azure_rtos.c
  group Application/User/FSBL/USBX/App
    ../../FSBL/USBX/App/: tx_execution_profile.c ux_device_descriptors.c app_usbx_device.c app_usbx.c ux_device_audio.c ux_device_audio_play.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../FSBL/Core/Src/: system_stm32n6xx_fsbl.c
  group Drivers/BSP/STM32N6570-DK
    ../../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_usbpd_pwr.c stm32n6570_discovery_bus.c stm32n6570_discovery_audio.c
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/tcpp0203/: tcpp0203.c tcpp0203_reg.c
    ../../../../../../../Drivers/BSP/Components/wm8904/: wm8904.c wm8904_reg.c
  group Middlewares/STM32_USBPD_Library
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32N6XX/src/: usbpd_timersserver.c usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_NOPD_CM55_Keil.lib
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_ll_exti.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_adc.c stm32n6xx_hal_adc_ex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_cortex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c stm32n6xx_ll_rcc.c stm32n6xx_ll_utils.c stm32n6xx_hal_mdf.c stm32n6xx_hal_rif.c stm32n6xx_hal_sai.c stm32n6xx_hal_sai_ex.c stm32n6xx_ll_ucpd.c stm32n6xx_ll_gpio.c stm32n6xx_ll_dma.c stm32n6xx_hal_pcd.c stm32n6xx_hal_pcd_ex.c stm32n6xx_ll_usb.c
  group Middlewares/usbx/UX Device Class AUDIO
    ../../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_audio_activate.c ux_device_class_audio_change.c ux_device_class_audio_control_request.c ux_device_class_audio_deactivate.c ux_device_class_audio_entry.c ux_device_class_audio_frame_write.c ux_device_class_audio_initialize.c ux_device_class_audio_ioctl.c ux_device_class_audio_read_thread_entry.c ux_device_class_audio_sample_read8.c ux_device_class_audio_sample_read16.c ux_device_class_audio_sample_read24.c ux_device_class_audio_sample_read32.c ux_device_class_audio_stream_get.c ux_device_class_audio_unitialize.c ux_device_class_audio10_control_process.c ux_device_class_audio20_control_process.c ux_device_class_audio_feedback_get.c ux_device_class_audio_feedback_set.c ux_device_class_audio_feedback_thread_entry.c ux_device_class_audio_interrupt_send.c ux_device_class_audio_interrupt_thread_entry.c ux_device_class_audio_speed_get.c
  group Middlewares/usbx/UX Device Class AUDIO PLAYBACK
    ../../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_audio_read_frame_free.c ux_device_class_audio_read_frame_get.c ux_device_class_audio_reception_start.c
  group Middlewares/usbx/UX Device Controllers
    ../../../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_uninitialize.c ux_dcd_stm32_transfer_abort.c
  group Middlewares/usbx/Core System
    ../../../../../../../Middlewares/ST/usbx/common/core/src/: ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_thread_create.c ux_utility_thread_delete.c ux_utility_thread_identify.c ux_utility_thread_relinquish.c ux_utility_thread_resume.c ux_utility_thread_schedule_other.c ux_utility_thread_sleep.c ux_utility_thread_suspend.c ux_utility_timer_create.c ux_utility_timer_delete.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c ux_system_error_handler.c ux_system_initialize.c ux_system_uninitialize.c
  group Middlewares/usbx/UX Device CoreStack
    ../../../../../../../Middlewares/ST/usbx/common/core/src/: ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_uninitialize.c
  group Middlewares/threadx/Core
    ../../../../../../../Middlewares/ST/threadx/common/src/: tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_system_resume.c tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
    ../../../../../../../Middlewares/ST/threadx/ports/cortex_m55/ac6/src/: tx_thread_secure_stack_initialize.S tx_thread_secure_stack_allocate.S tx_thread_secure_stack_free.S txe_thread_secure_stack_free.c txe_thread_secure_stack_allocate.c tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_interrupt_disable.S tx_thread_interrupt_restore.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S
software components: CMSIS:CORE 5.6.0
