<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USBPD_DRP_DRD.ewp</path>
  </project>
  <batchBuild />
</workspace>
