# Keil uVision project Tx_SecureLEDToggle_TrustZone_FSBL.uvprojx, settings and files
target Tx_SecureLEDToggle_TrustZone_FSBL (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x341C0000-0x341FFFFF) IROM(0x34180400-0x341BFFFF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: Tx_SecureLEDToggle_TrustZone_FSBL +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N657xx,TX_INCLUDE_USER_DEFINE_FILE,TX_SINGLE_MODE_SECURE=1,NO_OTP_FUSE
  c include: ../../FSBL/Inc;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy;../../../../../../../Middlewares/ST/STM32_ExtMem_Manager;../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot;../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal;../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp;../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram;../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sdcard;../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/user;../../../../../../../Middlewares/ST/threadx/common/inc;../../../../../../../Middlewares/ST/threadx/ports/cortex_m55/ac6/inc;../../../../../../../Drivers/CMSIS/Include
  asm define: TX_INCLUDE_USER_DEFINE_FILE,TX_SINGLE_MODE_SECURE=1
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x34180400 size 0x3fc00
  memory RVCT9: RAM 0x341c0000 size 0x40000
  scatter file: stm32n657xx_axisram2_fsbl.sct
  group Application/MDK-ARM
    ../: startup_stm32n657xx_fsbl.c
  group Application/User/FSBL
    ../../FSBL/Src/: main.c extmem_manager.c stm32n6xx_it.c stm32n6xx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_bsec.c stm32n6xx_hal_cortex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c stm32n6xx_hal_xspi.c
  group Drivers/CMSIS
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot/: stm32_boot_lrun.c
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c stm32_sal_sd.c
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sdcard/: stm32_sdcard_driver.c
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/user/: stm32_user_driver.c
software components: CMSIS:CORE 5.6.0
