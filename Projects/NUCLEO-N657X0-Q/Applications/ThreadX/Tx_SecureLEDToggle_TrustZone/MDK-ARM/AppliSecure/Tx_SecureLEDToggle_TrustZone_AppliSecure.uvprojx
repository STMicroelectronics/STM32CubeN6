# Keil uVision project Tx_SecureLEDToggle_TrustZone_AppliSecure.uvprojx, settings and files
target Tx_SecureLEDToggle_TrustZone_AppliSecure (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x34064000-0x340FFFFF) IROM(0x34000400-0x34063FFF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: Tx_SecureLEDToggle_TrustZone_AppliSecure +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N657xx,TX_INCLUDE_USER_DEFINE_FILE,TX_SINGLE_MODE_SECURE=1
  c include: ../../AppliSecure/Inc;../../Secure_nsclib;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy;../../../../../../../Middlewares/ST/threadx/common/inc;../../../../../../../Middlewares/ST/threadx/ports/cortex_m55/ac6/inc;../../../../../../../Drivers/CMSIS/Include
  asm define: TX_INCLUDE_USER_DEFINE_FILE,TX_SINGLE_MODE_SECURE=1
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x34000400 size 0x63c00
  memory RVCT9: RAM 0x34064000 size 0x9c000
  scatter file: stm32n657xx_LRUN_s.sct
  link misc: --import_cmse_lib_out=../../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ../: startup_stm32n657xx.c
  group Application/User/AppliSecure
    ../../AppliSecure/Src/: main.c stm32n6xx_it.c stm32n6xx_hal_msp.c secure_nsc.c
  group Doc
    ../../: README.md
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_cortex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c stm32n6xx_hal_rif.c
  group Drivers/CMSIS
    ../../AppliSecure/Src/: system_stm32n6xx_s.c
software components: CMSIS:CORE 5.6.0
