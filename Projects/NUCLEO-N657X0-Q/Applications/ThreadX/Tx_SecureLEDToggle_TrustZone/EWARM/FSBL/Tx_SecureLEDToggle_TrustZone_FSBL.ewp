# IAR project Tx_SecureLEDToggle_TrustZone_FSBL.ewp, settings and files
configuration Tx_SecureLEDToggle_TrustZone_FSBL (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx; TX_INCLUDE_USER_DEFINE_FILE; TX_SINGLE_MODE_SECURE=1; NO_OTP_FUSE
  ICCARM.CCIncludePath2: ../../FSBL/Inc; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager; ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot; ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal; ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp; ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram; ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sdcard; ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/user; ../../../../../../../Middlewares/ST/threadx/common/inc; ../../../../../../../Middlewares/ST/threadx/ports/cortex_m55/iar/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: TX_INCLUDE_USER_DEFINE_FILE; TX_SINGLE_MODE_SECURE=1
  AARM.AUserIncludes: ../../FSBL/Inc; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager; ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot; ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal; ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp; ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram; ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sdcard; ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/user; ../../../../../../../Middlewares/ST/threadx/common/inc; ../../../../../../../Middlewares/ST/threadx/ports/cortex_m55/iar/inc; ../../../../../../../Drivers/CMSIS/Include
  OBJCOPY.OOCOutputFile: Tx_SecureLEDToggle_TrustZone_FSBL.bin
  ILINK.IlinkOutputFile: Tx_SecureLEDToggle_TrustZone_FSBL.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram2_fsbl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx_fsbl.s
  group Application/User/FSBL
    ../../FSBL/Src/: extmem_manager.c main.c stm32n6xx_hal_msp.c stm32n6xx_it.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_xspi.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot/: stm32_boot_lrun.c
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_sd.c stm32_sal_xspi.c
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sdcard/: stm32_sdcard_driver.c
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/user/: stm32_user_driver.c
