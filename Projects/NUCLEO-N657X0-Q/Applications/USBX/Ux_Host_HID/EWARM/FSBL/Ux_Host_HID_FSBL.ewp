# IAR project Ux_Host_HID_FSBL.ewp, settings and files
configuration Ux_Host_HID_FSBL (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx; USE_FULL_LL_DRIVER; TX_INCLUDE_USER_DEFINE_FILE; TX_SINGLE_MODE_SECURE=1; USBPD_PORT_COUNT=1; UX_INCLUDE_USER_DEFINE_FILE; _SRC; USBPDCORE_LIB_NO_PD; TCPP0203_SUPPORT
  ICCARM.CCIncludePath2: ../../FSBL/Core/Inc; ../../FSBL/AZURE_RTOS/App; ../../FSBL/USBPD/App; ../../FSBL/USBPD/Target; ../../FSBL/USBX/App; ../../FSBL/USBX/Target; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../../../../../../Middlewares/ST/threadx/common/inc; ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc; ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32N6XX/inc; ../../../../../../../Middlewares/ST/threadx/ports/cortex_m55/iar/inc; ../../../../../../../Middlewares/ST/usbx/common/core/inc; ../../../../../../../Middlewares/ST/usbx/ports/generic/inc; ../../../../../../../Middlewares/ST/usbx/common/usbx_stm32_host_controllers; ../../../../../../../Middlewares/ST/usbx/common/usbx_host_classes/inc; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Drivers/BSP/STM32N6xx_Nucleo; ../../../../../../../Drivers/BSP/Components/tcpp0203; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: TX_INCLUDE_USER_DEFINE_FILE; TX_SINGLE_MODE_SECURE=1
  AARM.AUserIncludes: ../../FSBL/Core/Inc; ../../FSBL/AZURE_RTOS/App; ../../FSBL/USBPD/App; ../../FSBL/USBPD/Target; ../../FSBL/USBX/App; ../../FSBL/USBX/Target; ../../../../../../../Drivers/BSP/STM32N6xx_Nucleo; ../../../../../../../Drivers/BSP/Components/tcpp0203; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../../../../../../Middlewares/ST/threadx/common/inc; ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc; ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32N6XX/inc; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src; ../../../../../../../Middlewares/ST/threadx/ports/cortex_m55/iar/inc; ../../../../../../../Middlewares/ST/usbx/common/core/inc; ../../../../../../../Middlewares/ST/usbx/ports/generic/inc; ../../../../../../../Middlewares/ST/usbx/common/usbx_stm32_host_controllers; ../../../../../../../Middlewares/ST/usbx/common/usbx_host_classes/inc; ../../../../../../../Drivers/CMSIS/Include
  OBJCOPY.OOCOutputFile: Ux_Host_HID_FSBL.bin
  ILINK.IlinkOutputFile: Ux_Host_HID_FSBL.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram2_fsbl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx_fsbl.s
  group Application/User/FSBL/AZURE_RTOS/App
    ../../FSBL/AZURE_RTOS/App/: app_azure_rtos.c
  group Application/User/FSBL/Core
    ../../FSBL/Core/Src/: app_threadx.c gpdma.c gpio.c main.c stm32n6xx_hal_msp.c stm32n6xx_hal_timebase_tim.c stm32n6xx_it.c tx_initialize_low_level.S ucpd.c usart.c usb_otg.c
  group Application/User/FSBL/USBPD/App
    ../../FSBL/USBPD/App/: usbpd.c usbpd_dpm_core.c usbpd_pwr_if.c usbpd_usb_if.c
  group Application/User/FSBL/USBPD/Target
    ../../FSBL/USBPD/Target/: usbpd_dpm_user.c usbpd_pwr_user.c
  group Application/User/FSBL/USBX/App
    ../../FSBL/USBX/App/: app_usbx.c app_usbx_host.c ux_host_keyboard.c ux_host_mouse.c
  group Doc
    ../../: README.md
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/tcpp0203/: tcpp0203.c tcpp0203_reg.c
  group Drivers/BSP/STM32N6xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32N6xx_Nucleo/: stm32n6xx_nucleo.c stm32n6xx_nucleo_bus.c stm32n6xx_nucleo_usbpd_pwr.c
  group Drivers/CMSIS
    ../../FSBL/Core/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_adc.c stm32n6xx_hal_adc_ex.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_hcd.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_ll_dma.c stm32n6xx_ll_exti.c stm32n6xx_ll_gpio.c stm32n6xx_ll_rcc.c stm32n6xx_ll_ucpd.c stm32n6xx_ll_usb.c stm32n6xx_ll_utils.c
  group Middlewares/STM32_USBPD_Library
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32N6XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_NOPD_CM55_wc32.a
  group Middlewares/threadx/Core
    ../../../../../../../Middlewares/ST/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
    ../../../../../../../Middlewares/ST/threadx/ports/cortex_m55/iar/src/: tx_iar.c tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_secure_stack_allocate.s tx_thread_secure_stack_free.s tx_thread_secure_stack_initialize.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s txe_thread_secure_stack_allocate.c txe_thread_secure_stack_free.c
  group Middlewares/usbx/Core System
    ../../../../../../../Middlewares/ST/usbx/common/core/src/: ux_system_error_handler.c ux_system_initialize.c ux_system_uninitialize.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_pci_class_scan.c ux_utility_pci_read.c ux_utility_pci_write.c ux_utility_physical_address.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_thread_create.c ux_utility_thread_delete.c ux_utility_thread_identify.c ux_utility_thread_relinquish.c ux_utility_thread_resume.c ux_utility_thread_schedule_other.c ux_utility_thread_sleep.c ux_utility_thread_suspend.c ux_utility_timer_create.c ux_utility_timer_delete.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c
  group Middlewares/usbx/UX Host Class HID Core
    ../../../../../../../Middlewares/ST/usbx/common/usbx_host_classes/src/: ux_host_class_hid_activate.c ux_host_class_hid_client_register.c ux_host_class_hid_client_search.c ux_host_class_hid_configure.c ux_host_class_hid_deactivate.c ux_host_class_hid_descriptor_parse.c ux_host_class_hid_entry.c ux_host_class_hid_field_decompress.c ux_host_class_hid_global_item_parse.c ux_host_class_hid_idle_get.c ux_host_class_hid_idle_set.c ux_host_class_hid_instance_clean.c ux_host_class_hid_interrupt_endpoint_search.c ux_host_class_hid_item_data_get.c ux_host_class_hid_local_item_parse.c ux_host_class_hid_main_item_parse.c ux_host_class_hid_periodic_report_start.c ux_host_class_hid_periodic_report_stop.c ux_host_class_hid_report_add.c ux_host_class_hid_report_callback_register.c ux_host_class_hid_report_compress.c ux_host_class_hid_report_decompress.c ux_host_class_hid_report_descriptor_get.c ux_host_class_hid_report_get.c ux_host_class_hid_report_id_get.c ux_host_class_hid_report_item_analyse.c ux_host_class_hid_report_set.c ux_host_class_hid_resources_free.c ux_host_class_hid_transfer_request_completed.c
  group Middlewares/usbx/UX Host Class HID Keyboard
    ../../../../../../../Middlewares/ST/usbx/common/usbx_host_classes/src/: ux_host_class_hid_keyboard_activate.c ux_host_class_hid_keyboard_callback.c ux_host_class_hid_keyboard_deactivate.c ux_host_class_hid_keyboard_entry.c ux_host_class_hid_keyboard_ioctl.c ux_host_class_hid_keyboard_key_get.c ux_host_class_hid_keyboard_thread.c
  group Middlewares/usbx/UX Host Class HID Mouse
    ../../../../../../../Middlewares/ST/usbx/common/usbx_host_classes/src/: ux_host_class_hid_mouse_activate.c ux_host_class_hid_mouse_buttons_get.c ux_host_class_hid_mouse_callback.c ux_host_class_hid_mouse_deactivate.c ux_host_class_hid_mouse_entry.c ux_host_class_hid_mouse_position_get.c ux_host_class_hid_mouse_wheel_get.c
  group Middlewares/usbx/UX Host Controllers
    ../../../../../../../Middlewares/ST/usbx/common/usbx_stm32_host_controllers/: ux_hcd_stm32_callback.c ux_hcd_stm32_controller_disable.c ux_hcd_stm32_ed_obtain.c ux_hcd_stm32_endpoint_create.c ux_hcd_stm32_endpoint_destroy.c ux_hcd_stm32_endpoint_reset.c ux_hcd_stm32_entry.c ux_hcd_stm32_frame_number_get.c ux_hcd_stm32_initialize.c ux_hcd_stm32_interrupt_handler.c ux_hcd_stm32_least_traffic_list_get.c ux_hcd_stm32_periodic_schedule.c ux_hcd_stm32_port_disable.c ux_hcd_stm32_port_enable.c ux_hcd_stm32_port_reset.c ux_hcd_stm32_port_resume.c ux_hcd_stm32_port_status_get.c ux_hcd_stm32_port_suspend.c ux_hcd_stm32_power_down_port.c ux_hcd_stm32_power_on_port.c ux_hcd_stm32_request_bulk_transfer.c ux_hcd_stm32_request_control_transfer.c ux_hcd_stm32_request_periodic_transfer.c ux_hcd_stm32_request_trans_finish.c ux_hcd_stm32_request_trans_prepare.c ux_hcd_stm32_request_transfer.c ux_hcd_stm32_transfer_abort.c
  group Middlewares/usbx/UX Host CoreStack
    ../../../../../../../Middlewares/ST/usbx/common/core/src/: ux_host_stack_bandwidth_check.c ux_host_stack_bandwidth_claim.c ux_host_stack_bandwidth_release.c ux_host_stack_class_call.c ux_host_stack_class_device_scan.c ux_host_stack_class_get.c ux_host_stack_class_instance_create.c ux_host_stack_class_instance_destroy.c ux_host_stack_class_instance_get.c ux_host_stack_class_instance_verify.c ux_host_stack_class_interface_scan.c ux_host_stack_class_register.c ux_host_stack_class_unregister.c ux_host_stack_configuration_descriptor_parse.c ux_host_stack_configuration_enumerate.c ux_host_stack_configuration_instance_create.c ux_host_stack_configuration_instance_delete.c ux_host_stack_configuration_interface_get.c ux_host_stack_configuration_interface_scan.c ux_host_stack_configuration_set.c ux_host_stack_delay_ms.c ux_host_stack_device_address_set.c ux_host_stack_device_configuration_activate.c ux_host_stack_device_configuration_deactivate.c ux_host_stack_device_configuration_get.c ux_host_stack_device_configuration_reset.c ux_host_stack_device_configuration_select.c ux_host_stack_device_descriptor_read.c ux_host_stack_device_get.c ux_host_stack_device_remove.c ux_host_stack_device_resources_free.c ux_host_stack_device_string_get.c ux_host_stack_endpoint_instance_create.c ux_host_stack_endpoint_instance_delete.c ux_host_stack_endpoint_reset.c ux_host_stack_endpoint_transfer_abort.c ux_host_stack_enum_thread_entry.c ux_host_stack_hcd_register.c ux_host_stack_hcd_thread_entry.c ux_host_stack_hcd_transfer_request.c ux_host_stack_hcd_unregister.c ux_host_stack_hnp_polling_thread_entry.c ux_host_stack_initialize.c ux_host_stack_interface_endpoint_get.c ux_host_stack_interface_instance_create.c ux_host_stack_interface_instance_delete.c ux_host_stack_interface_set.c ux_host_stack_interface_setting_select.c ux_host_stack_interfaces_scan.c ux_host_stack_new_configuration_create.c ux_host_stack_new_device_create.c ux_host_stack_new_device_get.c ux_host_stack_new_endpoint_create.c ux_host_stack_new_interface_create.c ux_host_stack_rh_change_process.c ux_host_stack_rh_device_extraction.c ux_host_stack_rh_device_insertion.c ux_host_stack_role_swap.c ux_host_stack_transfer_request.c ux_host_stack_transfer_request_abort.c ux_host_stack_uninitialize.c
