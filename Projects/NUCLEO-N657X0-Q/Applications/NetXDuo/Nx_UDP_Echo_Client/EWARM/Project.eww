<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\Nx_UDP_Echo_Client_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
