<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\SAI_TDM_I2S_LoopbackDMA_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
